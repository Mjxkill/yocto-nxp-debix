IMAGE_INSTALL:append = " flutter-sdk dart-sdk flutter-embedded"
