# V9.2-step5e : ajoute build native pour lsp-plugins-native qui DEPENDS sur
# libsndfile1-native (binaire host génère samples preview .wav).
BBCLASSEXTEND += "native"
