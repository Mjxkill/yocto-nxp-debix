# V9.2-step5g : ajoute build native pour lsp-plugins-native chain.
BBCLASSEXTEND += "native"
