FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-imx8mp-disable-caam-enable-legacy.patch"
