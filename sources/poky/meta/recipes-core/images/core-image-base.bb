SUMMARY = "A console-only image that fully supports the target device \
hardware."

# John_gao del yocto logs IMAGE_FEATURES += "splash"

LICENSE = "MIT"

inherit core-image
